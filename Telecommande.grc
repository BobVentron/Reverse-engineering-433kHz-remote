options:
  parameters:
    generate_options: qt_gui
    id: Telecommande
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: A
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 'Tab_envoye@1 : 0,0,1,4'
    label: A
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: A_et_B
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 'Tab_envoye@2 : 0,0,1,4'
    label: A_et_B
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: A_et_B_et_C
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 'Tab_envoye@2 : 1,0,1,4'
    label: A_et_B_et_C
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: A_et_B_et_C_et_D
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 'Tab_envoye@2 : 2,0,1,4'
    label: A_et_B_et_C_et_D
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: B
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 'Tab_envoye@1 : 1,0,1,4'
    label: B
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: C
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 'Tab_envoye@1 : 2,0,1,4'
    label: C
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: Code_A
  id: variable_qtgui_label
  parameters:
    gui_hint: 'Tab_envoye@0 : 2,0,1,1'
    label: 'Show_Code_A :'
    type: raw
    value: '[1,1,1,0,1,0,0,0,1,0,0,0,1,0,0,0]'
  states: {}
- name: Code_A_et_B
  id: variable_qtgui_label
  parameters:
    gui_hint: 'Tab_envoye@0 : 6,0,1,1'
    label: 'Show_Code_A_et_B :'
    type: raw
    value: '[1,1,1,0,1,1,1,0,1,0,0,0,1,0,0,0]'
  states: {}
- name: D
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 'Tab_envoye@1 : 3,0,1,4'
    label: D
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: Frequency
  id: variable
  parameters:
    value: '433920000'
  states: {}
- name: Prémbule
  id: variable_qtgui_label
  parameters:
    gui_hint: 'Tab_envoye@0 : 1,0,1,1'
    label: 'Prémbule :'
    type: raw
    value: '[1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0]'
  states: {}
- name: address_telec
  id: variable_qtgui_label
  parameters:
    gui_hint: 'Tab_envoye@0 : 0,0,1,1'
    label: 'address_telec :'
    type: raw
    value: '[1,1,1,0,1,1,1,0,1,0,0,0,1,0,0,0,1,0,0,0,1,0,0,0,1,1,1,0,1,0,0,0,1,1,1,0,1,1,1,0,1,1,1,0,1,0,0,0,1,1,1,0,1,0,0,0,1,0,0,0,1,0,0,0,1,0,0,0,1,0,0,0,1,0,0,0,1,0,0,0]'
  states: {}
- name: code_A_et_B_et_C
  id: variable_qtgui_label
  parameters:
    gui_hint: 'Tab_envoye@0 : 7,0,1,1'
    label: 'Show_code_A_et_B_et_C :'
    type: raw
    value: '[1,1,1,0,1,1,1,0,1,1,1,0,1,0,0,0]'
  states: {}
- name: code_A_et_B_et_C_et_D
  id: variable_qtgui_label
  parameters:
    gui_hint: 'Tab_envoye@0 : 8,0,1,1'
    label: 'Show_Code_A_et_B_et_C_et_D :'
    type: raw
    value: '[1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0]'
  states: {}
- name: code_B
  id: variable_qtgui_label
  parameters:
    gui_hint: 'Tab_envoye@0 : 3,0,1,1'
    label: 'Show_code_B :'
    type: raw
    value: '[1,0,0,0,1,1,1,0,1,0,0,0,1,0,0,0]'
  states: {}
- name: code_C
  id: variable_qtgui_label
  parameters:
    gui_hint: 'Tab_envoye@0 : 4,0,1,1'
    label: 'Show_Code_C :'
    type: raw
    value: '[1,0,0,0,1,0,0,0,1,1,1,0,1,0,0,0]'
  states: {}
- name: code_D
  id: variable_qtgui_label
  parameters:
    gui_hint: 'Tab_envoye@0 : 5,0,1,1'
    label: 'Show_Code_D :'
    type: raw
    value: '[1,0,0,0,1,0,0,0,1,0,0,0,1,1,1,0]'
  states: {}
- name: copyrightMB
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,1
    label: 'copyright :'
    type: string
    value: 2024 Bermond Michel et Soleilhac Bastien
  states: {}
- name: entre_Binaire
  id: variable_qtgui_entry
  parameters:
    gui_hint: 'Tab_envoye@3 '
    label: 'Entrez liste :'
    type: raw
    value: (1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,1,1,1,0,1,1,1,1,0,1,1,1,1,0,1,0,0,0,1,1,1,1,0,1,0,0,0,1,0,0,0,1,0,0,0,1,1,1,1,0,1,0,0,0,1,1,1,1,0,1,0,0,0,1,1,1,1,0,1,1,1,1,0,1,1,1,0,1,1,1,0,1,0,0,0,1,0,0,0,1,0,0,0,1,1,1,1,0,1,0,0,0,1,1,1,0,1,0,0,0,1,0,0,0,1)
  states: {}
- name: envoye_bianire
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 'Tab_envoye@3 '
    label: Envoye
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: on_off_envoye
  id: variable_qtgui_toggle_switch
  parameters:
    cellalignment: '2'
    gui_hint: Tab_general@1:0,0,1,1
    initPressed: 'False'
    label: OFF-ON
    pressed: '1'
    released: '0'
    switchOffBackground: red
    type: int
    value: '0'
    verticalalignment: '2'
  states: {}
- name: on_off_recep
  id: variable_qtgui_toggle_switch
  parameters:
    cellalignment: '2'
    gui_hint: 'Tab_general@2 : 0,0,1,1'
    initPressed: 'False'
    label: OFF-ON
    pressed: '1'
    released: '0'
    switchOffBackground: red
    type: int
    value: '0'
  states: {}
- name: samp_rate_envoye
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: samp_rate_recep
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: Tab_aff_envoye
  id: qtgui_tab_widget
  parameters:
    gui_hint: Tab_general@1 :2,0,1,1
    label0: Affichage
    num_tabs: '1'
  states: {}
- name: Tab_aff_recep_1
  id: qtgui_tab_widget
  parameters:
    gui_hint: Tab_recep@0
    label0: Affichage
    num_tabs: '1'
  states: {}
- name: Tab_envoye
  id: qtgui_tab_widget
  parameters:
    gui_hint: Tab_general@1 :1,0,1,1
    label0: Info
    label1: Simu_Telecomande
    label2: Autre_Button
    label3: Tab 3
    num_tabs: '4'
  states: {}
- name: Tab_general
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,1
    label0: acceuil
    label1: envoye
    label2: récéption
    num_tabs: '3'
  states: {}
- name: Tab_recep
  id: qtgui_tab_widget
  parameters:
    gui_hint: 'Tab_general@2 '
    label0: demod
    num_tabs: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Frequency
    offset: '0'
    phase: '0'
    samp_rate: '1000000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '8'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: test.raw
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: A
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: D
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: envoye_bianire
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: B
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: A_et_B_et_C
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_2
  id: blocks_multiply_const_vxx
  parameters:
    const: C
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: A_et_B_et_C_et_D
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_3
  id: blocks_multiply_const_vxx
  parameters:
    const: on_off_recep
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_4
  id: blocks_multiply_const_vxx
  parameters:
    const: on_off_envoye
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_4_0
  id: blocks_multiply_const_vxx
  parameters:
    const: on_off_envoye
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_4_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: on_off_envoye
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_4_1
  id: blocks_multiply_const_vxx
  parameters:
    const: on_off_envoye
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_4_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: on_off_envoye
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_4_2
  id: blocks_multiply_const_vxx
  parameters:
    const: on_off_envoye
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_4_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: on_off_envoye
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_4_3
  id: blocks_multiply_const_vxx
  parameters:
    const: on_off_envoye
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_5
  id: blocks_multiply_const_vxx
  parameters:
    const: A_et_B
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '350'
    type: float
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: '350'
    type: float
  states: {}
- name: blocks_repeat_0_0_0
  id: blocks_repeat
  parameters:
    interp: '350'
    type: float
  states: {}
- name: blocks_repeat_0_1
  id: blocks_repeat
  parameters:
    interp: '350'
    type: float
  states: {}
- name: blocks_repeat_0_1_0
  id: blocks_repeat
  parameters:
    interp: '350'
    type: float
  states: {}
- name: blocks_repeat_0_2
  id: blocks_repeat
  parameters:
    interp: '350'
    type: float
  states: {}
- name: blocks_repeat_0_2_0
  id: blocks_repeat
  parameters:
    interp: '350'
    type: float
  states: {}
- name: blocks_repeat_0_3
  id: blocks_repeat
  parameters:
    interp: '350'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.15'
    init: '0'
    low: '0.01'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: entre_Binaire
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class concat_source_block(gr.sync_block):
          """Bloc pour concaténer trois listes et les utiliser comme source de données."""
          
          def __init__(self, var1=None, var2=None, var3=None):
              gr.sync_block.__init__(self,
                  name="Concat Source Block",
                  in_sig=None,  # Pas d'entrées
                  out_sig=[np.float32])  # Sortie en float32
              
              # Initialisation des variables
              self.var1 = var1 if var1 is not None else []
              self.var2 = var2 if var2 is not None else []
              self.var3 = var3 if var3 is not None else []
              
              # Concaténation initiale
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Suivi de la position de lecture dans le résultat

          def set_var1(self, var1):
              """Met à jour var1 et recalcule le résultat."""
              self.var1 = var1
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Réinitialiser l'offset

          def set_var2(self, var2):
              """Met à jour var2 et recalcule le résultat."""
              self.var2 = var2
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Réinitialiser l'offset

          def set_var3(self, var3):
              """Met à jour var3 et recalcule le résultat."""
              self.var3 = var3
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Réinitialiser l'offset

          def work(self, input_items, output_items):
              """Envoie les données concaténées comme sortie."""
              noutput_items = len(output_items[0])

              # Calculer combien d'éléments nous pouvons copier à partir du résultat
              available_items = len(self.result) - self.offset
              items_to_copy = min(noutput_items, available_items)

              # Copier les éléments dans la sortie
              output_items[0][:items_to_copy] = self.result[self.offset:self.offset + items_to_copy]

              # Mettre à jour l'offset
              self.offset += items_to_copy

              # Si on atteint la fin du résultat, remettre l'offset à zéro pour répéter
              if self.offset >= len(self.result):
                  self.offset = 0  # Boucle à nouveau

              return items_to_copy
    var1: Prémbule
    var2: address_telec
    var3: code_D
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class concat_source_block(gr.sync_block):
          """Bloc pour concaténer trois listes et les utiliser comme source de données."""
          
          def __init__(self, var1=None, var2=None, var3=None):
              gr.sync_block.__init__(self,
                  name="Concat Source Block",
                  in_sig=None,  # Pas d'entrées
                  out_sig=[np.float32])  # Sortie en float32
              
              # Initialisation des variables
              self.var1 = var1 if var1 is not None else []
              self.var2 = var2 if var2 is not None else []
              self.var3 = var3 if var3 is not None else []
              
              # Concaténation initiale
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Suivi de la position de lecture dans le résultat

          def set_var1(self, var1):
              """Met à jour var1 et recalcule le résultat."""
              self.var1 = var1
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Réinitialiser l'offset

          def set_var2(self, var2):
              """Met à jour var2 et recalcule le résultat."""
              self.var2 = var2
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Réinitialiser l'offset

          def set_var3(self, var3):
              """Met à jour var3 et recalcule le résultat."""
              self.var3 = var3
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Réinitialiser l'offset

          def work(self, input_items, output_items):
              """Envoie les données concaténées comme sortie."""
              noutput_items = len(output_items[0])

              # Calculer combien d'éléments nous pouvons copier à partir du résultat
              available_items = len(self.result) - self.offset
              items_to_copy = min(noutput_items, available_items)

              # Copier les éléments dans la sortie
              output_items[0][:items_to_copy] = self.result[self.offset:self.offset + items_to_copy]

              # Mettre à jour l'offset
              self.offset += items_to_copy

              # Si on atteint la fin du résultat, remettre l'offset à zéro pour répéter
              if self.offset >= len(self.result):
                  self.offset = 0  # Boucle à nouveau

              return items_to_copy
    var1: Prémbule
    var2: address_telec
    var3: code_B
  states: {}
- name: epy_block_1_0_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class concat_source_block(gr.sync_block):
          """Bloc pour concaténer trois listes et les utiliser comme source de données."""
          
          def __init__(self, var1=None, var2=None, var3=None):
              gr.sync_block.__init__(self,
                  name="Concat Source Block",
                  in_sig=None,  # Pas d'entrées
                  out_sig=[np.float32])  # Sortie en float32
              
              # Initialisation des variables
              self.var1 = var1 if var1 is not None else []
              self.var2 = var2 if var2 is not None else []
              self.var3 = var3 if var3 is not None else []
              
              # Concaténation initiale
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Suivi de la position de lecture dans le résultat

          def set_var1(self, var1):
              """Met à jour var1 et recalcule le résultat."""
              self.var1 = var1
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Réinitialiser l'offset

          def set_var2(self, var2):
              """Met à jour var2 et recalcule le résultat."""
              self.var2 = var2
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Réinitialiser l'offset

          def set_var3(self, var3):
              """Met à jour var3 et recalcule le résultat."""
              self.var3 = var3
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Réinitialiser l'offset

          def work(self, input_items, output_items):
              """Envoie les données concaténées comme sortie."""
              noutput_items = len(output_items[0])

              # Calculer combien d'éléments nous pouvons copier à partir du résultat
              available_items = len(self.result) - self.offset
              items_to_copy = min(noutput_items, available_items)

              # Copier les éléments dans la sortie
              output_items[0][:items_to_copy] = self.result[self.offset:self.offset + items_to_copy]

              # Mettre à jour l'offset
              self.offset += items_to_copy

              # Si on atteint la fin du résultat, remettre l'offset à zéro pour répéter
              if self.offset >= len(self.result):
                  self.offset = 0  # Boucle à nouveau

              return items_to_copy
    var1: Prémbule
    var2: address_telec
    var3: code_A_et_B_et_C
  states: {}
- name: epy_block_1_0_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class concat_source_block(gr.sync_block):
          """Bloc pour concaténer trois listes et les utiliser comme source de données."""
          
          def __init__(self, var1=None, var2=None, var3=None):
              gr.sync_block.__init__(self,
                  name="Concat Source Block",
                  in_sig=None,  # Pas d'entrées
                  out_sig=[np.float32])  # Sortie en float32
              
              # Initialisation des variables
              self.var1 = var1 if var1 is not None else []
              self.var2 = var2 if var2 is not None else []
              self.var3 = var3 if var3 is not None else []
              
              # Concaténation initiale
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Suivi de la position de lecture dans le résultat

          def set_var1(self, var1):
              """Met à jour var1 et recalcule le résultat."""
              self.var1 = var1
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Réinitialiser l'offset

          def set_var2(self, var2):
              """Met à jour var2 et recalcule le résultat."""
              self.var2 = var2
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Réinitialiser l'offset

          def set_var3(self, var3):
              """Met à jour var3 et recalcule le résultat."""
              self.var3 = var3
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Réinitialiser l'offset

          def work(self, input_items, output_items):
              """Envoie les données concaténées comme sortie."""
              noutput_items = len(output_items[0])

              # Calculer combien d'éléments nous pouvons copier à partir du résultat
              available_items = len(self.result) - self.offset
              items_to_copy = min(noutput_items, available_items)

              # Copier les éléments dans la sortie
              output_items[0][:items_to_copy] = self.result[self.offset:self.offset + items_to_copy]

              # Mettre à jour l'offset
              self.offset += items_to_copy

              # Si on atteint la fin du résultat, remettre l'offset à zéro pour répéter
              if self.offset >= len(self.result):
                  self.offset = 0  # Boucle à nouveau

              return items_to_copy
    var1: Prémbule
    var2: address_telec
    var3: code_C
  states: {}
- name: epy_block_1_0_1_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class concat_source_block(gr.sync_block):
          """Bloc pour concaténer trois listes et les utiliser comme source de données."""
          
          def __init__(self, var1=None, var2=None, var3=None):
              gr.sync_block.__init__(self,
                  name="Concat Source Block",
                  in_sig=None,  # Pas d'entrées
                  out_sig=[np.float32])  # Sortie en float32
              
              # Initialisation des variables
              self.var1 = var1 if var1 is not None else []
              self.var2 = var2 if var2 is not None else []
              self.var3 = var3 if var3 is not None else []
              
              # Concaténation initiale
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Suivi de la position de lecture dans le résultat

          def set_var1(self, var1):
              """Met à jour var1 et recalcule le résultat."""
              self.var1 = var1
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Réinitialiser l'offset

          def set_var2(self, var2):
              """Met à jour var2 et recalcule le résultat."""
              self.var2 = var2
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Réinitialiser l'offset

          def set_var3(self, var3):
              """Met à jour var3 et recalcule le résultat."""
              self.var3 = var3
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Réinitialiser l'offset

          def work(self, input_items, output_items):
              """Envoie les données concaténées comme sortie."""
              noutput_items = len(output_items[0])

              # Calculer combien d'éléments nous pouvons copier à partir du résultat
              available_items = len(self.result) - self.offset
              items_to_copy = min(noutput_items, available_items)

              # Copier les éléments dans la sortie
              output_items[0][:items_to_copy] = self.result[self.offset:self.offset + items_to_copy]

              # Mettre à jour l'offset
              self.offset += items_to_copy

              # Si on atteint la fin du résultat, remettre l'offset à zéro pour répéter
              if self.offset >= len(self.result):
                  self.offset = 0  # Boucle à nouveau

              return items_to_copy
    var1: Prémbule
    var2: address_telec
    var3: code_A_et_B_et_C_et_D
  states: {}
- name: epy_block_1_0_2
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class concat_source_block(gr.sync_block):
          """Bloc pour concaténer trois listes et les utiliser comme source de données."""
          
          def __init__(self, var1=None, var2=None, var3=None):
              gr.sync_block.__init__(self,
                  name="Concat Source Block",
                  in_sig=None,  # Pas d'entrées
                  out_sig=[np.float32])  # Sortie en float32
              
              # Initialisation des variables
              self.var1 = var1 if var1 is not None else []
              self.var2 = var2 if var2 is not None else []
              self.var3 = var3 if var3 is not None else []
              
              # Concaténation initiale
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Suivi de la position de lecture dans le résultat

          def work(self, input_items, output_items):
              """Envoie les données concaténées comme sortie."""
              noutput_items = len(output_items[0])

              # Calculer combien d'éléments nous pouvons copier à partir du résultat
              available_items = len(self.result) - self.offset
              items_to_copy = min(noutput_items, available_items)

              # Copier les éléments dans la sortie
              output_items[0][:items_to_copy] = self.result[self.offset:self.offset + items_to_copy]

              # Mettre à jour l'offset
              self.offset += items_to_copy

              # Si on atteint la fin du résultat, remettre l'offset à zéro pour répéter
              if self.offset >= len(self.result):
                  self.offset = 0  # Boucle à nouveau

              return items_to_copy
    var1: Prémbule
    var2: address_telec
    var3: Code_A
  states: {}
- name: epy_block_1_0_2_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class concat_source_block(gr.sync_block):
          """Bloc pour concaténer trois listes et les utiliser comme source de données."""
          
          def __init__(self, var1=None, var2=None, var3=None):
              gr.sync_block.__init__(self,
                  name="Concat Source Block",
                  in_sig=None,  # Pas d'entrées
                  out_sig=[np.float32])  # Sortie en float32
              
              # Initialisation des variables
              self.var1 = var1 if var1 is not None else []
              self.var2 = var2 if var2 is not None else []
              self.var3 = var3 if var3 is not None else []
              
              # Concaténation initiale
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Suivi de la position de lecture dans le résultat

          def set_var1(self, var1):
              """Met à jour var1 et recalcule le résultat."""
              self.var1 = var1
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Réinitialiser l'offset

          def set_var2(self, var2):
              """Met à jour var2 et recalcule le résultat."""
              self.var2 = var2
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Réinitialiser l'offset

          def set_var3(self, var3):
              """Met à jour var3 et recalcule le résultat."""
              self.var3 = var3
              self.result = np.array(self.var1 + self.var2 + self.var3, dtype=np.float32)
              self.offset = 0  # Réinitialiser l'offset

          def work(self, input_items, output_items):
              """Envoie les données concaténées comme sortie."""
              noutput_items = len(output_items[0])

              # Calculer combien d'éléments nous pouvons copier à partir du résultat
              available_items = len(self.result) - self.offset
              items_to_copy = min(noutput_items, available_items)

              # Copier les éléments dans la sortie
              output_items[0][:items_to_copy] = self.result[self.offset:self.offset + items_to_copy]

              # Mettre à jour l'offset
              self.offset += items_to_copy

              # Si on atteint la fin du résultat, remettre l'offset à zéro pour répéter
              if self.offset >= len(self.result):
                  self.offset = 0  # Boucle à nouveau

              return items_to_copy
    var1: Prémbule
    var2: address_telec
    var3: Code_A_et_B
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: Frequency
    samplerate: samp_rate_envoye
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: iio_pluto_source_0_0
  id: iio_pluto_source
  parameters:
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: Frequency
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '2000000'
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '500'
    decim: '1'
    gain: '1'
    samp_rate: '100000'
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_recep
    fc: '0'
    fftsize: '1024'
    gui_hint: 'Tab_aff_recep_1@0 : 0,0,1,1'
    name: '"Avant Filtre"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_recep
    fc: '0'
    fftsize: '1024'
    gui_hint: 'Tab_aff_recep_1@0 : 0,1,1,1'
    name: '"Apres filtre"'
    type: float
  states: {}
- name: qtgui_graphicitem_0
  id: qtgui_graphicitem
  parameters:
    file: C:\Users\basti\OneDrive\Bureau\IUT\Semestre 3\SAE 31 - Etude et mise en oeuvre d’un système de transmission\Capture d’écran 2024-10-25 151529.png
    fixedsize: 'True'
    gui_hint: 'Tab_general@0: 0,1,1,1'
    height: '640'
    width: '640'
  states: {}
- name: qtgui_graphicitem_0_0
  id: qtgui_graphicitem
  parameters:
    file: C:\Users\basti\OneDrive\Bureau\IUT\Semestre 3\SAE 31 - Etude et mise en oeuvre d’un système de transmission\Capture d’écran 2024-10-25 152410.png
    fixedsize: 'True'
    gui_hint: Tab_general@0:1,0,1,1
    height: '-1'
    width: '-1'
  states: {}
- name: qtgui_graphicitem_0_0_0
  id: qtgui_graphicitem
  parameters:
    file: C:\Users\basti\OneDrive\Bureau\IUT\Semestre 3\SAE 31 - Etude et mise en oeuvre d’un système de transmission\Capture d’écran 2024-10-25 152410.png
    fixedsize: 'True'
    gui_hint: 'Tab_general@0: 0,0,1,1'
    height: '750'
    width: '750'
  states: {}
- name: qtgui_graphicitem_0_0_1
  id: qtgui_graphicitem
  parameters:
    file: C:\Users\basti\OneDrive\Bureau\IUT\Semestre 3\SAE 31 - Etude et mise en oeuvre d’un système de transmission\Capture d’écran 2024-10-25 152410.png
    fixedsize: 'True'
    gui_hint: 'Tab_general@0: 0,2,1,1'
    height: '750'
    width: '750'
  states: {}
- name: qtgui_graphicitem_0_0_1_0
  id: qtgui_graphicitem
  parameters:
    file: C:\Users\basti\OneDrive\Bureau\IUT\Semestre 3\SAE 31 - Etude et mise en oeuvre d’un système de transmission\Capture d’écran 2024-10-25 152410.png
    fixedsize: 'True'
    gui_hint: Tab_general@1 :3,0,4,1
    height: '750'
    width: '750'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_recep
    fc: '0'
    fftsize: '1024'
    gui_hint: 'Tab_recep@0 '
    name: '"Apres demodulation"'
    type: float
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_envoye
    fc: '0'
    fftsize: '1024'
    gui_hint: 'Tab_aff_envoye@0  : 0,0,1,1'
    name: '"Binaire"'
    plotwaterfall: 'False'
    type: float
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_recep
    fc: '0'
    fftsize: '1024'
    gui_hint: 'Tab_recep@0 '
    name: '"Binaire"'
    type: float
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_envoye
    fc: '0'
    fftsize: '1024'
    gui_hint: 'Tab_aff_envoye@0 : 0,1,1,1'
    name: '"Singal envoyer"'
    plotwaterfall: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_0_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_recep
    fc: '0'
    fftsize: '1024'
    gui_hint: 'Tab_recep@0 '
    name: '"Singal reçu"'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', low_pass_filter_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', iio_pluto_sink_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_1_0_0, '0', blocks_add_xx_0, '7']
- [blocks_multiply_const_vxx_1_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1_1_0, '0', blocks_add_xx_0, '5']
- [blocks_multiply_const_vxx_1_2, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_1_2_0, '0', blocks_add_xx_0, '6']
- [blocks_multiply_const_vxx_1_3, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_multiply_const_vxx_1_3, '0', qtgui_sink_x_0_1_0, '0']
- [blocks_multiply_const_vxx_1_4, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_1_4_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_multiply_const_vxx_1_4_0_0, '0', blocks_multiply_const_vxx_1_0_0, '0']
- [blocks_multiply_const_vxx_1_4_1, '0', blocks_multiply_const_vxx_1_1, '0']
- [blocks_multiply_const_vxx_1_4_1_0, '0', blocks_multiply_const_vxx_1_1_0, '0']
- [blocks_multiply_const_vxx_1_4_2, '0', blocks_multiply_const_vxx_1_2, '0']
- [blocks_multiply_const_vxx_1_4_2_0, '0', blocks_multiply_const_vxx_1_2_0, '0']
- [blocks_multiply_const_vxx_1_4_3, '0', blocks_multiply_const_vxx_1_5, '0']
- [blocks_multiply_const_vxx_1_5, '0', blocks_add_xx_0, '4']
- [blocks_multiply_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_const_vxx_1_4, '0']
- [blocks_repeat_0_0, '0', blocks_multiply_const_vxx_1_4_1, '0']
- [blocks_repeat_0_0_0, '0', blocks_multiply_const_vxx_1_4_1_0, '0']
- [blocks_repeat_0_1, '0', blocks_multiply_const_vxx_1_4_2, '0']
- [blocks_repeat_0_1_0, '0', blocks_multiply_const_vxx_1_4_2_0, '0']
- [blocks_repeat_0_2, '0', blocks_multiply_const_vxx_1_4_0, '0']
- [blocks_repeat_0_2_0, '0', blocks_multiply_const_vxx_1_4_0_0, '0']
- [blocks_repeat_0_3, '0', blocks_multiply_const_vxx_1_4_3, '0']
- [blocks_threshold_ff_0, '0', blocks_file_sink_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_sink_x_0_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0_2_0, '0']
- [epy_block_1_0, '0', blocks_repeat_0_2, '0']
- [epy_block_1_0_0, '0', blocks_repeat_0_0, '0']
- [epy_block_1_0_0_0, '0', blocks_repeat_0_0_0, '0']
- [epy_block_1_0_1, '0', blocks_repeat_0_1, '0']
- [epy_block_1_0_1_0, '0', blocks_repeat_0_1_0, '0']
- [epy_block_1_0_2, '0', blocks_repeat_0, '0']
- [epy_block_1_0_2_0, '0', blocks_repeat_0_3, '0']
- [iio_pluto_source_0_0, '0', blocks_multiply_const_vxx_1_3, '0']
- [low_pass_filter_0, '0', blocks_threshold_ff_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
